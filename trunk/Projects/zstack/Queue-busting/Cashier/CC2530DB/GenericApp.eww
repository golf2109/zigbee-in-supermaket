<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GenericApp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\SampleApp\CC2530DB\SampleApp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\SimpleApp\CC2530DB\SimpleApp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


